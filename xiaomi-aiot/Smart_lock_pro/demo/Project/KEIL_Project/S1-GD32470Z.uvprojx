# Keil uVision project S1-GD32470Z.uvprojx, settings and files
target S1-GD32470Z (6230000::V6.23::ARMCLANG)
  device: GD32F470ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S1-GD32450Z +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F450,USE_USB_HS,USE_USB_FS,USE_ULPI_PHY
  c include: ..\..\Project;..\..\..\Library\Firmware\GD32F4xx_standard_peripheral\Include;..\..\..\Library\Utilities;..\..\..\Library\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\..\Library\Firmware\CMSIS;..\Application\inc;..\GD32F470Z_BSP\inc;..\..\..\Library\Firmware\GD32F4xx_usb_library\device\class\hid\Include;..\..\..\Library\Firmware\GD32F4xx_usb_library\device\core\Include;..\..\..\Library\Firmware\GD32F4xx_usb_library\driver\Include;..\..\..\Library\Firmware\GD32F4xx_usb_library\ustd\common;..\..\..\Library\Firmware\GD32F4xx_usb_library\ustd\class\hid;..\..\..\Library\Firmware\GD32F4xx_usb_library\host\core\Include;..\..\..\Library\Firmware\GD32F4xx_usb_library\host\class\hid\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Application/src/: main.c
  group GD32F470Z_BSP
    ../GD32F470Z_BSP/src/: i2c.c gd32f470z_eval.c s1.c e1.c e2.c e3.c s2.c s5.c s7.c c2.c uart.c c3.c
  group GD32F4xx_Peripherals
    ../../../Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ../../../Library/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group StartUp
    ../../../Library/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f470.s
  group doc
    ../../../: Readme.txt
